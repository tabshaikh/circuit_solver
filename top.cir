R1 NET2 NET3 2.2Kohm
C1 NET3 0 1UF
V1 NET2 NET1 SINE ( 0 5 0.060Khz 0.0S 0 )
V2 NET1 0 SINE ( 0 5 0.090Khz 0.0S 0 )
